## boards/myd/Kconfig
```kconfig
config TARGET_MYD_JA7100T
	bool "MYD JA7100T (Artix-7 customizada)"
	help
	  Placa customizada baseada em Artix-7 com WR PTP Core.
```
